# IAR project STM32-demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F411CE ST STM32F411CE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F411xE; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: C:\Users\randl\OneDrive\Desktop\STM32-demo\Libraries\STM32F4xx_StdPeriph_Driver\inc; C:\Users\randl\OneDrive\Desktop\STM32-demo\Driver; C:\Users\randl\OneDrive\Desktop\STM32-demo\Users; C:\Users\randl\OneDrive\Desktop\STM32-demo\Libraries\CMSIS\CoreSupport; C:\Users\randl\OneDrive\Desktop\STM32-demo\Libraries\StartUp; C:\Users\randl\OneDrive\Desktop\STM32-demo\Libraries\CMSIS\DeviceSupport
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: STM32-demo.srec
  ILINK.IlinkOutputFile: STM32-demo.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  group Driver
    ../Driver/: rh_clock.cpp rh_timer.cpp
  group Libraries/CMSIS/CoreSupport
    ../Libraries/CMSIS/CoreSupport/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm4.h
  group Libraries/StartUp
    ../Libraries/StartUp/iar/: startup_stm32f411xe.s
    ../Libraries/StartUp/: system_stm32f4xx.c system_stm32f4xx.h
  group Libraries/STM32F4xx_StdPeriph_Driver
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c
  group Users
    ../Users/: main.cc
